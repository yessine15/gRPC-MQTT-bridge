require recipes-core/images/core-image-minimal.bb
#IMAGE_INSTALL:append = " helloworld"

IMAGE_INSTALL:append = " grpchellow"


